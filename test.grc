<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1.e-1</value></param>
<param><key>decay_rate</key><value>1.e-2</value></param>
<param><key>gain</key><value>5.e-1</value></param>
<param><key>max_gain</key><value>1</value></param>
<param><key>reference</key><value>3.e-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-250</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>D:\en_p\trames_ads_raw_2.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>6.e-2</value></param>
<param><key>gain_omega</key><value>2.e-3</value></param>
<param><key>mu</key><value>1.e-2</value></param>
<param><key>omega_relative_limit</key><value>5.e-6*100</value></param>
<param><key>omega</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>import numpy as np
  
from gnuradio import gr

from time import sleep 

from math import sqrt,atan , pi

class blk(gr.sync_block):
  def __init__(self, viewDebug= 0 ):
  
        gr.sync_block.__init__(self,
                            name ='Le Machin de Python' , 
                            in_sig= [np.int8],
                            out_sig= None
        ) 
        self.viewDebug = viewDebug
        self.trame = np.array([] , np.int8)
        self.table ="#ABCDEFGHIJKLMNOPQRSTUVWXYZ#####_###############0123456789#####"
   
  def decodetrame112(self,S):
      df= int(S[0:5], 2)
      if df== 17 :
         ca = int(S[5:8] , 2) 
         ica024 = int(S[8:32], 2)
         tct=0

         if tc in range(9 ,19):
            km= "" 
            alt= S[40:52]
            q= alt[7] 
            n = alt[:7]+ alt[8:]
            if q == "1":
                 n=int (n,2) * 25
            else:
                 n= int(n,2) * 100
            km = ( n -1000) * 0.3048
            print tc, " " ,hex(ica024) , " ", km , "m"
            tct=1

         if  tc in range(1,5):
            ec= int(S[37:40], 2)
            ident = ""   
            for i in range(0, 8):
                  c= int(S[40 + i * 6:46 + i * 6], 2 ) 
                  ident= ident + self.table[c]
            print tc, " " , hex(ica024) , " " , ident 
            tct= 1

         if tc == 19:
            st = int(S[37:40])
            swe = S[45]
            vwe = int(S[46:56], 2)
            sns = S[56]
            vns = int(S[57:67], 2)
            vwe = float(vwe)
            vns = float(vns)
            if vns ==0 : vns = 0.0001
            vitesse = sqrt(vwe * vwe + vns * vns)  / 0.539957
            heading = atan(vwe / vns) * (360.0 / (2.0 * pi))
            if swe == "0" and sns == "1" :
                    heading = 180.0 - heading
            if swe == "1" and sns == "1" :
                    heading = 180.0 +heading
            if swe == "1" and sns == "0" :         
                    heading == 360.0 - heading   
            print tc, " ", hex(ica024), "vitesse = ", int(vitesse), " km/h", " cap = ", int(heading), "deg"
            tct = 1

         if tct == 0:
                print tc, "tc non traite"
      else:
         if self.viewDebug:
                     print df,"***********************trame112******************************"

  def decodetrame56(self, S):
            df = int(S[0:5], 2)
            if self.viewDebug:
                    print df, " ***********trame52*********  "
            return

  def decodetrame (self):

        S = ""
        for i in range(0, 224):
            if self.trame[0] == self.trame[1]:
                    break
            if self.trame[0] == 1:
                    S = S + "1"
            else:
                    S = S + "0"
            self.trame = self.trame[2:]

        if len(S) == 112:

            self.decodetrame112(S)

        if len(S) == 56:

            self.decodetrame56(S)

  def work(self, input_items, output_items):
        """ads-b decoder"""
        self.trame = np.append(self.trame, input_items[0])
        
        bits1 = np.where(self.trame ==1)[0]
        if len(bits1) == 0:
                self.trame = self.trame[-1:]

        while len(bits1) &gt; 0:
                self.trame = self.trame[bits1[0]:]
                bits1 = bits1[1:]
                if len(self.trame) &gt;241:
                    sr = 0
                    for i in range(0, 14):
                       sr = (sr &lt;&lt; 1) | self.trame[i]

                    if sr == 0b10000101000000:
                        self.trame = self.trame[14:]
                        self.decodetrame()
                        bits1 = np.where(self.trame == 1)[0]
                    
                    if len(bits1) == 0: self.trame = self.trame[-1:]; break;
                else:
                    break
        return len(input_items[0])






</value></param>
<param><key>viewDebug</key><value>0</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
